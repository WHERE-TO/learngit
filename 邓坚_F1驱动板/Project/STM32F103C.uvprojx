# Keil uVision project STM32F103C.uvprojx, settings and files
target MotorDriver (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Mylib;..\Libraries;..\CM3;..\User;..\Mylib\ecode;..\Mylib\motor;..\System\pid;..\System\timer;..\Mylib\can
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CM3
    ../CM3/: system_stm32f10x.c core_cm3.c startup_stm32f10x_md.s
  group Libraries
    ../Libraries/: misc.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_exti.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Mylib
    ../Mylib/motor/: motor.c
    ../Mylib/can/: can.c
  group System
    ../System/timer/: timer.c
    ../System/pid/: pid.c
