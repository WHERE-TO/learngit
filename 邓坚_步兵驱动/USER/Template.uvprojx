# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\SYSTEM\timer;..\HARDWARE\SURDEWHEEL;..\HARDWARE\MPU6050;..\HARDWARE\CAN;..\HARDWARE\REMOTE;..\HARDWARE\MOTOR_820R;..\SYSTEM\pid;..\SYSTEM\control;..\USER;..\HARDWARE\MOTOR_6223
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group SYSTEM
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/pid/: pid.c
    ../SYSTEM/control/: control.c
  group README
    ../: readme.txt
  group HARDWARE
    ../HARDWARE/SURDEWHEEL/: surgewheel.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/MOTOR_820R/: motor_820r.c
    ../HARDWARE/MOTOR_6223/: motor6223.c
