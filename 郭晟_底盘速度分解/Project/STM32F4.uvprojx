# Keil uVision project STM32F4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\CM4;..\User;..\Libraries\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CM4
    ../CM4/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group Libraries
    ../Libraries/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c
  group User
    ../User/: main.c stm32f4xx_it.c Remotecontrol.c can.c pid.c tim.c ChassisControl.c
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2
